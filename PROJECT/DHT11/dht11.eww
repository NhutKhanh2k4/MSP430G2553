<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\BALANCING ROBOT\Balancing_Robot.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\dht11.ewp</path>
    </project>
    <batchBuild />
</workspace>
