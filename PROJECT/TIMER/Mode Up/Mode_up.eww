<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Mode_up.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\TEST\test.ewp</path>
    </project>
    <batchBuild />
</workspace>
