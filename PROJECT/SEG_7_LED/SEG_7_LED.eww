<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SEG_7_LED.ewp</path>
    </project>
    <batchBuild />
</workspace>
